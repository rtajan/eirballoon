options:
  parameters:
    generate_options: no_gui
    id: test_hackrf
    output_language: python
    title: test_hackrf
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/virgil/grosBallon/eirballoon/py_hackrf/text.txt
    length: '17'
    repeat: 'True'
    type: complex
  states: {}
- name: fp
  id: parameter
  parameters:
    label: fp
    short_id: f
    type: eng_float
    value: 2.45e9
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: fp
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
